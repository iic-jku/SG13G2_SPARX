** sch_path: schematic/sparx_powdet_sbd.sch
* (c) 2026 H. Pretl, ICD@JKU
**.subckt sparx_powdet_sbd rfin vout vss vdd vref
*.ipin rfin
*.opin vout
*.iopin vss
*.ipin vdd
*.opin vref
XR1 bias1 rfin_int [expr {$lvs_ignore ? {vss} : {sub}}] rsil w=0.5e-6 l=2.5e-6 m=1 mm_ok=1
XD1 rfin_int bb_int [expr {$lvs_ignore ? {vss} : {sub}}] schottky_nbl1 Nx=1 Ny=1
XC2 bias1 vss cap_cmim w=10e-6 l=10e-6 m=30 mm_ok=1
XM2 vout bb_int vdd [expr {$lvs_ignore ? {vdd} : {nw}}] sg13_lv_pmos w=100u l=0.13u ng=20 m=1 mm_ok=1
XM1 vout bb_int vss [expr {$lvs_ignore ? {vss} : {sub}}] sg13_lv_nmos w=50u l=0.13u ng=20 m=1 mm_ok=1
XR2 vout bb_int [expr {$lvs_ignore ? {vss} : {sub}}] rppd w=0.5e-6 l=1.5e-6 m=1 b=0 mm_ok=1
XM4 vref bias2 vdd [expr {$lvs_ignore ? {vdd} : {nw}}] sg13_lv_pmos w=10u l=0.13u ng=2 m=1 mm_ok=1
XM3 vref bias2 vss [expr {$lvs_ignore ? {vss} : {sub}}] sg13_lv_nmos w=5u l=0.13u ng=2 m=1 mm_ok=1
XC3 vdd vss cap_cmim w=10e-6 l=10e-6 m=28 mm_ok=1
XD2 net1 bias2 [expr {$lvs_ignore ? {vss} : {sub}}] schottky_nbl1 Nx=1 Ny=1
XR3 bias1 vdd [expr {$lvs_ignore ? {vss} : {sub}}] rhigh w=0.5e-6 l=2e-6 m=1 b=0 mm_ok=1
XR4 vref bias2 [expr {$lvs_ignore ? {vss} : {sub}}] rppd w=0.5e-6 l=1.5e-6 m=1 b=0 mm_ok=1
XR5 bias1 net1 [expr {$lvs_ignore ? {vss} : {sub}}] rsil w=0.5e-6 l=2.5e-6 m=1 mm_ok=1
XMdummy1 vss vss vss [expr {$lvs_ignore ? {vss} : {sub}}] sg13_lv_nmos w=5u l=0.13u ng=2 m=1 mm_ok=1
XMdummy2 vdd vdd vdd [expr {$lvs_ignore ? {vdd} : {nw}}] sg13_lv_pmos w=10u l=0.13u ng=2 m=1 mm_ok=1
XC1 rfin rfin_int cap_cmim w=10e-6 l=10e-6 m=1 mm_ok=1
XRntap vdd [expr {$lvs_ignore ? {vdd} : {nw}}] ntap1 R=4.353 w=9.62e-6 l=17.16e-6 rw=0.3e-6
XRptap vss [expr {$lvs_ignore ? {vss} : {sub}}] ptap1 R=4.998 w=6.86e-6 l=16.54e-6 rw=0.3e-6
XC4 vdd vss cap_cmim w=6.8e-6 l=9e-6 m=2 mm_ok=1
**.ends
.end
